FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-restrict-maximum-resolution-it-support-during-rk_vop.patch"

